# Keil uVision project CAR.uvprojx, settings and files
target CAR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE\SERVO;..\HARDWARE\CAN;..\HARDWARE\KEY;..\HARDWARE\DMA;..\SYSTEM\dma;..\SYSTEM\can;..\CONTROL\move;..\CONTROL\system;..\HARDWARE\UNDM;..\SYSTEM\tim;..\SYSTEM\iwdg;..\CONTROL\respond
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CONTROL
    ../CONTROL/move/: move.c
    ../CONTROL/system/: system.c
    ../CONTROL/respond/: respond.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/can/: can.c
    ../SYSTEM/dma/: dma.c
    ../SYSTEM/tim/: tim.c
    ../SYSTEM/iwdg/: iwdg.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/UNDM/: undm.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_iwdg.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
